# IAR project suite1.STM32F1xx.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: STM32F107xC ST STM32F107xC
  ICCARM.CCIncludePath2: ../../../../../../../CoX_Peripheral\CoX_Peripheral_STM32F1xx\libcox; ../../../lib; ../src; ../../../../../../../CoX_Peripheral\CoX_Peripheral_STM32F1xx\testframe; ../../../../../../LCD_Character/HX8347-G/Character_LCD_HX8347-G_Driver/lib
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: 5.srec
  ILINK.IlinkOutputFile: suite1.STM32F1xx.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group COX/CoX_Driver/Seven_Segment
    ../../../lib/: Seven_Segment.c Seven_Segment.h
  group COX/CoX_Peripheral/inc
    ../../../../../../../CoX_Peripheral/CoX_Peripheral_STM32F1xx/libcox/: xcore.h xdebug.h xgpio.h xhw_gpio.h xhw_ints.h xhw_memmap.h xhw_nvic.h xhw_sysctl.h xhw_types.h xhw_uart.h xsysctl.h xuart.h
  group COX/CoX_Peripheral/src
    ../../../../../../../CoX_Peripheral/CoX_Peripheral_STM32F1xx/libcox/: xcore.c xdebug.c xgpio.c xsysctl.c xuart.c
  group ewarm
    ../../../../../../../CoX_Peripheral/CoX_Peripheral_STM32F1xx/startup/src/: startup_ewarm.s
  group Source
    ../: main.c
  group test/testcase
    ../src/: STMPE811_Test.c testcase.c testcase.h
  group test/testframe
    ../../../../../../../CoX_Peripheral/CoX_Peripheral_STM32F1xx/testframe/: test.c test.h testport.c
