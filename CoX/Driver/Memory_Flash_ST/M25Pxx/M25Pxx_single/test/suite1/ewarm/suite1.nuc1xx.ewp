# IAR project suite1.nuc1xx.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ILINK.IlinkOutputFile: suite1.nuc1xx.out
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath: dl-stnl0.a
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group COX/CoX_Driver/M25Pxx_single
    ../../../lib/: hw_M25Pxx.h M25Pxx.c M25Pxx.h
  group COX/CoX_Peripheral/inc
    ../../../../../../../CoX_Peripheral/CoX_Peripheral_NUC1xx/libcox/: xcore.h xdebug.h xdma.h xgpio.h xhw_gpio.h xhw_ints.h xhw_memmap.h xhw_nvic.h xhw_spi.h xhw_sysctl.h xhw_types.h xhw_uart.h xspi.h xsysctl.h xuart.h
  group COX/CoX_Peripheral/src
    ../../../../../../../CoX_Peripheral/CoX_Peripheral_NUC1xx/libcox/: xcore.c xgpio.c xspi.c xsysctl.c xuart.c
  group ewarm
    ./: startup_ewarm.s
  group Source
    ../: main.c
  group test/testcase
    ../src/: M25PxxTest.c testcase.c testcase.h
  group test/testframe
    ../../../../../../../resource/testframe/: test.c test.h testport.c
