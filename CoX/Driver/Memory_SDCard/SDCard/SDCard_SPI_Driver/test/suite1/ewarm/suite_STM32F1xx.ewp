# IAR project suite_STM32F1xx.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: STM32F10xxC ST STM32F10xxC
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\..\CoX_Peripheral\CoX_Peripheral_STM32F1xx\libcox; ..\..\..\..\..\..\..\resource\testframe; ..\src; ..\..\..\lib
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: suite_STM32F1xx.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CoX/CoX_Driver/SDCard
    ../../../lib/: hw_sdcard.h sdcard.c sdcard.h
  group CoX/CoX_Peripheral/inc
    ../../../../../../../CoX_Peripheral/CoX_Peripheral_STM32F1xx/libcox/: xcore.h xdebug.h xgpio.h xhw_gpio.h xhw_i2c.h xhw_ints.h xhw_memmap.h xhw_nvic.h xhw_spi.h xhw_sysctl.h xhw_types.h xhw_uart.h xspi.h xsysctl.h xuart.h
  group CoX/CoX_Peripheral/src
    ../../../../../../../CoX_Peripheral/CoX_Peripheral_STM32F1xx/libcox/: xcore.c xdebug.c xgpio.c xspi.c xsysctl.c xuart.c
  group ewarm
    ../../../../../../../CoX_Peripheral/CoX_Peripheral_STM32F1xx/startup/src/: startup_ewarm.s
  group testframe/testcase
    ../src/: test1.c testcase.c testcase.h
  group testframe/testframe
    ../../../../../../../CoX_Peripheral/CoX_Peripheral_STM32F1xx/testframe/: main.c test.c test.h testport.c
